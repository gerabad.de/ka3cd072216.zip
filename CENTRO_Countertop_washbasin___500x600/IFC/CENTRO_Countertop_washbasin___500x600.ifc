Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2017-08-31T16:35:35
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140223_1515(x64) - Exporter 2015.0.2014.0223 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Aug 31 16:35:35 2017 * Host: PC-20170117ZWHS * Database: C:\Users\ADMINI~1\AppData\Local\Temp\{2A6E04EC-45FD-4585-8238-D56D1EE5500D}\ifc * Database version: 5507 * Database creation date: Thu Aug 31 16:35:31 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Aug 31 16:35:31 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Aug 31 16:35:31 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 12, 46, 799999; RefLongitude: -71, -1, -58, -799999; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowTerminal: CENTRO AUFSATZWASCHTISCH 3057 500x600, KDW010083:CENTRO AUFSATZWASCHTISCH 3057 500x600:126221
In: Level 1
Material: Acier, chromé, Kaldewei
Pset_ManufacturerTypeInformation - Manufacturer: Kaldewei
Pset_DistributionFlowElementCommon - Reference: CENTRO AUFSATZWASCHTISCH 3057 500x600
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.732831 m2; Height: 900 mm; Volume: 0.00229404 m3
Identity Data - Mark: 1; Manufacturer: Kaldewei; Model: CENTROAUFSATZWASCHTISCH; Type Name: CENTRO AUFSATZWASCHTISCH 3057 500x600; URL: https://www.kaldewei.co.uk/products/washbasins/detail/product/centro-aufsatzwaschtisch-12-cm/; Version: 4
Other - Category: Plumbing Fixtures; Family: KDW010083: CENTRO AUFSATZWASCHTISCH 3057 500x600; Family and Type: KDW010083: CENTRO AUFSATZWASCHTISCH 3057 500x600; Type: KDW010083: CENTRO AUFSATZWASCHTISCH 3057 500x600; Type Id: KDW010083: CENTRO AUFSATZWASCHTISCH 3057 500x600; Family Name: KDW010083; Features: https://www.kaldewei.co.uk/products/washbasins/detail/product/centro-aufsatzwaschtisch-12-cm/?tx_wkkaldeweiproducts_product%5Bmodellnr%5D=3057&cHash=828c3f1f60f394ec4ca6813732e2d6a6#tabConfiguration; Finish: https://n/a; ManufacturerEmail: info@kaldewei.de; ObjectPicture: https://www.kaldewei.co.uk/products/washbasins/detail/product/centro-aufsatzwaschtisch-12-cm/?tx_wkkaldeweiproducts_product%5Bmodellnr%5D=3057&cHash=828c3f1f60f394ec4ca6813732e2d6a6#tabConfiguration; Polantis code: KDW010083; SerialNumber: 3057; Sustainability: https://kaldewei-fa.secure.footprint.net/data/sprachen/englisch/prospekte/rest/Steel_Enamel_Baths_and_Shower_Trays.pdf
Phasing - Phase Created: New Construction
Data - ColourOptions: https://www.kaldewei.co.uk/inspiration/material/colours/; ConnectingDimensions: n/a; Durability: https://www.kaldewei.de/fileadmin/data/sprachen/alle/pdfs/leistungserkla__rungBW-DW-WT-0216Web.pdf; IntegralAccessories: https://www.kaldewei.co.uk/products/washbasins/detail/product/centro-aufsatzwaschtisch-12-cm/?tx_wkkaldeweiproducts_product%5Bmodellnr%5D=3057&cHash=828c3f1f60f394ec4ca6813732e2d6a6#tabConfiguration; Name: CENTROAUFSATZWASCHTISCH; NominalHeight: 120 mm; Shape: Inset Countertop; Size: 500x600; SupportFrame: https://www.kaldewei.co.uk/products/washbasins/detail/product/centro-aufsatzwaschtisch-12-cm/?tx_wkkaldeweiproducts_product%5Bmodellnr%5D=3057&cHash=828c3f1f60f394ec4ca6813732e2d6a6#tabConfiguration; VolumeToOverflowMaximum: n/a; WarrantyDurationParts: 30; WarrantyDurationUnit: Year; WaterSupplyOverflowAndWasteHolesOverflow: n/a; WaterSupplyOverflowAndWasteHolesWaste: n/a; WaterSupplyOverflowAndWasteHolesWaterSupply: n/a; Weight: 13
General - Author: Polantis; ManufacturerCountry: GERMANY; ManufacturerName: KALDEWEI; ManufacturerURL: https://www.kaldewei.com; ObjectName: CENTRO Countertop washbasin 500x600; ObjectNorm: EN 14688EU DECLARATION OF PERFORMANCE(https://www.kaldewei.de/fileadmin/data/sprachen/alle/pdfs/leistungserkla__rungBW-DW-WT-0216Web.pdf); ObjectURL: https://www.kaldewei.co.uk/products/washbasins/detail/product/centro-aufsatzwaschtisch-12-cm/; ProductInformation: Model No.3057: Fusion of minimalism and simple elegance- luxurious look – integrates perfectly both in modern and traditional bathroom settings - circle taken as the basic shape echoes in the perfectly integrated enamelled waste- washbasin surround with ample space for individual accessories- matching counterpart to the Centro bath- designed by Anke Salomon; Revision: 1; TechnicalDataURL: https://kaldewei.typo-live.web-factory.de/fileadmin/data/sprachen/englisch/techdata/KADBE_WT_CENTRO___________3057_.pdf; Uniclass 2015: Pr_40_20_96; UNSPSCCode: 30181504; UNSPSCNames: Sinks; WarrantyStartDate: https://www.kaldewei.co.uk/fileadmin/data/sprachen/englisch/prospekte/rest/GB_GUARANTEE__CARE_AND_INSTALLATION_INSTRUCTIONS.pdf
Materials and Finishes - Finition: Kaldewei; Material: steel enamel; Metal: Acier, chromé; PanelMaterial: n/a
